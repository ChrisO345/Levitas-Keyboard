# Repository ChrisO345/Levitas-Keyboard

## KiCad design pcb/right/keyboard_pcb.kicad_pcb

Board: 2 copper layers, 140.0 x 85.7 mm, 32 parts (9 on the bottom side), 27 nets.

Parts:
H1, H1#2, H2, H3, H4, H4#2, H4#3: MountingHole; MountingHole_2.2mm_M2-8mm
J1: TRRS; TRRS-PJ-320A
K00, K01, K02, K03, K04, K05, K10, K11, K12, K13, K14, K15, K20, K21, K22, K23, K24, K25, K30, K31, K32: KEYSW; Kailh_socket_PG1350_optional
R1: 5k6; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R2: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
U2: Pico; RPi_Pico_SMD_TH

Connections:
/k00: K00.1, U2.15 (GPIO11)
/k01: K01.1, U2.11 (GPIO8)
/k02: K02.1, U2.7 (GPIO5)
/k03: K03.1, U2.4 (GPIO2)
/k04: K04.1, U2.27 (GPIO21)
/k05: K05.1, U2.29 (GPIO22)
/k10: K10.1, U2.16 (GPIO12)
/k11: K11.1, U2.12 (GPIO9)
/k12: K12.1, U2.9 (GPIO6)
/k13: K13.1, U2.5 (GPIO3)
/k14: K14.1, U2.25 (GPIO19)
/k15: K15.1, U2.26 (GPIO20)
/k20: K20.1, U2.17 (GPIO13)
/k21: K21.1, U2.14 (GPIO10)
/k22: K22.1, U2.10 (GPIO7)
/k23: K23.1, U2.6 (GPIO4)
/k24: K24.1, U2.22 (GPIO17)
/k25: K25.1, U2.24 (GPIO18)
/k30: K30.1, U2.21 (GPIO16)
/k31: K31.1, U2.19 (GPIO14)
/k32: K32.1, U2.20 (GPIO15)
GND: J1.3 (RING1), K00.2, K01.2, K02.2, K03.2, K04.2, K05.2, K10.2, K11.2, K12.2, K13.2, K14.2, K15.2, K20.2, K21.2, K22.2, K23.2, K24.2, K25.2, K30.2, K31.2, K32.2, R2.2, U2.3 (GND), U2.8 (GND), U2.13 (GND), U2.18 (GND), U2.23 (GND), U2.28 (GND), U2.33 (AGND), U2.38 (GND)
VBUS: R1.1, U2.40 (VBUS)
VCC: J1.2 (TIP), U2.39 (VSYS)
rx: J1.4 (RING2), U2.2 (GPIO1)
tx: J1.1 (SLEEVE), U2.1 (GPIO0)
vbus_sense: R1.2, R2.1, U2.34 (GPIO28_ADC2)

File pcb/left/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"H1_2, H1, H2, H3, H4_3, H4_2, H4",MountingHole_2.2mm_M2-8mm,7,MountingHole,
J1,TRRS-PJ-320A,1,TRRS,
"K00, K01, K02, K03, K04, K05, K10, K11, K12, K13, K14, K15, K20, K21, K22, K23, K24, K25, K30, K31, K32",Kailh_socket_PG1350_optional,21,KEYSW,
R1,1206,1,5k6,
R2,1206,1,10k,
U2,RPi_Pico_SMD_TH,1,Pico,

## Commit log

2024-07-08 Adding the License
